options:
  parameters:
    author: Ivan Antony Babu
    generate_options: qt_gui
    id: USRPFM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Centre_freq
  id: variable_qtgui_range
  parameters:
    start: '435000000'
    step: '1'
    stop: '915000000'
    value: '435000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: '480000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: Centre_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Centre_freq
    dev_addr: '"serial= 313FAA7"'
    gain0: '40'
    otw: sc16
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', analog_wfm_rcv_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
