options:
  parameters:
    author: Ivan Antony Babu
    category: Custom
    generate_options: qt_gui
    id: FMTrans
    output_language: python
    title: FM Transmiter
  states: {}

blocks:
- name: frec
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '65000000'
    step: '100000'
    stop: '74000000'
    value: '65000000'
  states: {}
- name: quadrature_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.25'
    stop: '10'
    value: '1'
  states: {}
- name: analog_wfm_tx_0_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '2400000'
    fh: '75000'
    max_dev: 75e3
    quad_rate: '2400000'
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\CREMA\Desktop\GNU\Test_Video\BPSK_test.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: quadrature_rate
    fc: frec
    fftsize: '4096'
    name: '"FM"'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: frec
    fftsize: '4096'
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '50'
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '27000000'
    center_freq0: 'frec '
    gain0: '20'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_wfm_tx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_wfm_tx_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_wfm_tx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
